options:
  parameters:
    author: Paul Boven
    copyright: GPLv3
    generate_options: no_gui
    id: ATA_FX_corr
    output_language: python
    run_options: run
    title: ATA FX Correlator
  states: {}

blocks:
- name: chans
  id: variable
  parameters:
    value: '512'
  states: {}
- name: delay
  id: variable
  parameters:
    comment: |-
      Baseline delay, in seconds.
      Gets updated by ZMQ messages
    value: '9e-7'
  states: {}
- name: delay_constant
  id: variable
  parameters:
    comment: |-
      Additional delay on both channels,
      so delay never goes negative.
    value: 9e-7 + 14e-7
  states: {}
- name: f_obs
  id: variable
  parameters:
    comment: Sky Frrequency, in Hz
    value: 1350e6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: fractional_delay
  id: variable
  parameters:
    value: np.exp(-1j*np.linspace(-np.pi, np.pi, chans, endpoint = False) * (samp_rate * (delay + delay_constant) - np.floor(samp_rate * (delay + delay_constant) + 0.5)))
  states: {}
- name: integer_delay
  id: variable
  parameters:
    value: int(np.floor(samp_rate*(delay+delay_constant)+0.5))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: chans
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: chans
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Integer Delay
    delay: integer_delay
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    comment: Fixed Delay
    delay: int(delay_constant * samp_rate)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: source+'-'+str(int(samp_rate/1e5)/10)+'MSps-fringe+auto-'+str(chans)+'bins-IQ-float '+timestamp
    type: complex
    vlen: chans
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: chans
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(record * samp_rate)
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(record * samp_rate)
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/10000)
    type: complex
    vlen: chans
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/10000)
    type: complex
    vlen: chans
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
    vlen: chans
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: chans
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Fringe Rotation and
      Fractional Delay
    const: '[np.exp(1j*-2*np.pi*(f_obs * delay - np.floor(f_obs*delay + 0.5)))]*chans * fractional_delay'
    type: complex
    vlen: chans
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '23'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: delay
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: record
  id: parameter
  parameters:
    label: Recording Length (s)
    type: intx
    value: '60'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source.set_lo_source("external", "lo1", 1)
    comment: |-
      Snippet to enable LO export
      on the N320/N321
    section: main_after_init
  states: {}
- name: source
  id: parameter
  parameters:
    label: Source Name
    type: str
    value: '''CasA'''
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: str(datetime.now())
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: fc
    center_freq1: fc
    clock_rate: '0.0'
    clock_source0: external
    clock_source1: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dev_addr: '"addr0=10.11.1.50, addr1=10.11.1.52"'
    dev_args: '"master_clock_rate=200e6"'
    gain0: gaindB
    gain1: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sd_spec1: A:0
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:50000
    timeout: '100'
    type: complex
    vlen: chans
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://localhost:50001
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_delay_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_head_0, '0', blocks_delay_0, '0']
- [blocks_head_0_0, '0', blocks_delay_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_interleave_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_0, '0', zeromq_pub_sink_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [uhd_usrp_source, '0', blocks_head_0, '0']
- [uhd_usrp_source, '1', blocks_head_0_0, '0']
- [zeromq_sub_msg_source_0, out, gpredict_MsgPairToVar_0, inpair]

metadata:
  file_format: 1
