options:
  parameters:
    author: paul
    generate_options: no_gui
    id: ATA_FX_corr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chans
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters:
    vlen: chans
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''CasA-fringe-256bins-IQ-float''+timestamp'
    type: float
    vlen: chans
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: complex
    vlen: chans
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
    vlen: chans
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: chans
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: carrier frequency
    short_id: c
    type: eng_float
    value: 629e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1.0,]*chans'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1.0,]*chans'
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'False'
    shift: 'True'
    type: complex
    window: '[1.0,]*chans'
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '23'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: str(datetime.now())
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: fc
    center_freq1: fc
    clock_rate: '0.0'
    clock_source0: external
    clock_source1: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dev_addr: '"addr0=10.11.2.61, addr1=10.11.2.71"'
    dev_args: '"master_clock_rate=200e6"'
    gain0: gaindB
    gain1: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    num_mboards: '2'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:0
    sd_spec1: A:0
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:50000
    timeout: '100'
    type: float
    vlen: chans
  states: {}

connections:
- [blocks_complex_to_float_0_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_interleave_0, '1']
- [blocks_integrate_xx_0, '0', fft_vxx_1, '0']
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_0, '0', zeromq_pub_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_complex_to_float_0_0, '0']
- [uhd_usrp_source, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
