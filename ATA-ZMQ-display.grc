options:
  parameters:
    author: Paul Boven
    copyright: GPLv3
    description: https://github.com/PE1NUT/ATA-FX
    generate_options: qt_gui
    id: ATA_ZMQ_display
    output_language: python
    title: ATA-FX Real Time Fringe Display
  states: {}

blocks:
- name: chans
  id: variable
  parameters:
    value: '512'
  states: {}
- name: frac_delay
  id: variable
  parameters:
    value: np.exp(1j* (phase + np.linspace(-np.pi, np.pi, chans, endpoint = False) * phase_slope))
  states: {}
- name: integration
  id: variable
  parameters:
    value: '500'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '0'
  states: {}
- name: phase_slope
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-20'
    step: '0.01'
    stop: '20'
    value: '0'
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters:
    vlen: chans
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: chans
  states: {}
- name: blocks_deinterleave_1
  id: blocks_deinterleave
  parameters:
    blocksize: int(chans/2)
    comment: FFTshift
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integration
    type: complex
    vlen: chans
  states: {}
- name: blocks_integrate_xx_0_0_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integration
    type: complex
    vlen: chans
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    blocksize: int(chans/2)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    comment: Zoom in on fringe location
    m: '64'
    n: chans
    offset: int(chans/2)-32
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Phase and Delay
      Correction
    const: frac_delay
    type: complex
    vlen: chans
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: To improve latency
    interp: '40'
    type: complex
    vlen: chans
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    comment: To improve latency
    interp: '40'
    type: float
    vlen: chans
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: chans
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: chans
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: chans
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[1.0,]*chans'
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: Polar plot of the Fringe
    grid: 'True'
    gui_hint: 0,0,2,1
    size: chans*4
    style1: '1'
    type: complex
    xmax: '1500'
    xmin: '-1500'
    ymax: '1500'
    ymin: '-1500'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: Zoom view on Fringe
    grid: 'True'
    gui_hint: 0,1,1,1
    name: FX Xcorr on ATA - CasA 1350 MHz 50MS/s
    vlen: '64'
    x_axis_label: '"Offset (samples)"'
    x_start: '-32'
    x_step: '1'
    x_units: '"bins"'
    y_axis_label: Fringe Amplitude
    ymax: 5e10
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    comment: Phase vs Frequency
    gui_hint: 1,1,1,1
    name: FX Xcorr on ATA - CasA 1350 MHz 50MS/s
    vlen: chans
    x_axis_label: Frequency (MHz)
    x_start: 1350 - samp_rate/2e6
    x_step: samp_rate/chans/1e6
    x_units: '"bins"'
    y_axis_label: Phase (rad)
    ymax: '4'
    ymin: '-4'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    type: eng_float
    value: 50e6
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.1.50.11:50000
    timeout: '100'
    type: complex
    vlen: chans
  states: {}

connections:
- [blocks_complex_to_arg_0_0, '0', blocks_repeat_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_deinterleave_1, '0', blocks_interleave_0, '1']
- [blocks_deinterleave_1, '1', blocks_interleave_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_repeat_0, '0']
- [blocks_integrate_xx_0_0_0_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_interleave_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_integrate_xx_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_repeat_0_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_deinterleave_1, '0']
- [fft_vxx_0, '0', blocks_integrate_xx_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
