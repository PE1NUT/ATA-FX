options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: default_is_fine
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chans
  id: variable
  parameters:
    value: '256'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: float
    vlen: chans
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '4'
    type: float
    vlen: chans
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '4'
    type: float
    vlen: chans
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
    vlen: chans
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
    vlen: chans
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: FX Xcorr on ATA - CasA 1350 MHz
    nconnections: '2'
    vlen: chans
    x_axis_label: '"Offset (samples)"'
    x_start: '0'
    x_step: '1'
    x_units: '"bins"'
    ymax: 5e10
    ymin: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    type: eng_float
    value: 50e6
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.1.50.11:50000
    timeout: '100'
    type: float
    vlen: chans
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_deinterleave_0, '1', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_repeat_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '1']
- [zeromq_sub_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
